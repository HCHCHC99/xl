# Keil uVision project template - 副本 - 副本 (2).uvprojx, settings and files
target template_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F46x.1.0.6
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: ../source;../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../drivers/cmsis/Include;../../../../drivers/hc32_ll_driver/inc;..\..\RTT;..\..\Dev;..\..\Adp;..\..\App;..\..\Utils;..\..\ws
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f460.s
    ../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group source
    ../source/: main.c
  group driver
    ../../../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_icg.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
  group Readme
    ../: Readme.txt
  group Adp
    ../../Adp/: Adapter.c Adc.c Aos.c Gpio_io.c Hardware.c Motor_hall.c Pwm.c Sysclk.c Template_Pwm.c Timer0_Unit1.c Timer0_Unit2.c timer6_timebase.c Dma.c hc32f46x_flash.c rs485.c Comm_HAL.c tmr4_pwm.c Usart3_HW.c Usart3_IO.c Usart3_Vofa.c Usart3_Vofa_Runner.c Vofa.c encoder.c
  group RTT
    ../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Dev
    ../../Dev/: dev_hall.c dev_io.c dev_motor.c dev_power.c dev_pwm.c device_manager.c EventBus.c dev_adc.c dev_motor_hall.c dev_sensor.c dev_voltage.c dev_rturn.c
  group App
    ../../App/: App_Motor_Project.c App_FaultHandler.c App_Comm.c App_Realtime.c Protocol_ModbusRtu.c test_Vofa.c
  group Utils
    ../../Utils/: TickTimer.c lock.c msg_queue.c param_manager.c ring_buf.c rtt_manager.c Params.c dev_pid.c
  group ws
    ../../ws/: dev_commutation.c hall_sensor_3ch.c dev_comm_runner.c cur_loop.c I.c Bemf.c pos_loop.c speed_loop.c foc.c foc_math.c foc_core.c foc_curloop.c foc_openloop.c foc_scope.c foc_calib.c foc_obs.c foc_smo.c foc_pll.c foc_20_cal.c foc_51_rs.c foc_52_ldlq.c foc_53_flx.c foc_luen.c foc_60_luen.c foc_24_dcal.c foc_25_calangle.c foc_26_olf.c foc_27_dcl.c foc_28_dci.c foc_29_drun.c foc_30_ramp.c foc_31_iqpi.c foc_32_lockiq.c foc_40_speed.c foc_41_drun.c foc_5_svpwm.c foc_45_smo.c foc_47_smoif.c
target template_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.6
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: ..\source;../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../drivers/cmsis/Include;../../../../drivers/hc32_ll_driver/inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
